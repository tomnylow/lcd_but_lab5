# Keil uVision project MDR32_MELT_MT-10T7.uvprojx, settings and files
target K1986BE92QI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDR32_MELT16S2S
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MDR_MELT_16S2S;.\App;.\HW_CONFIG;.\MELT_MT-10T7
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./App/: main.c
  group hw_config
    ./HW_CONFIG/: hw_config.c
  group MELT_MT-10T7
    ./MELT_MT-10T7/: melt_mt_10t7.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5
